<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>spectro_radiometer</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Spectral and Radiometry Receiver</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>actual_dec_label</value></param>
<param><key>value</key><value>spectro_helper.get_decln(ui_decln,decfile,tp_pacer)</value></param>
<param><key>gui_hint</key><value>main_tab@0:1,1,1,1</value></param>
<param><key>label</key><value>Actual DEC</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ang</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@1:1,0,1,3</value></param>
<param><key>label</key><value>Phase Angle Adjust</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-180</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>180</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>anno_status</value></param>
<param><key>value</key><value>spectro_helper.do_annotation(ira,declination,baseline,annotation,srate*0.8,abw,ifreq,srate,prefix)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>annotation</value></param>
<param><key>value</key><value>""</value></param>
<param><key>gui_hint</key><value>main_tab@0:2,1,1,2</value></param>
<param><key>label</key><value>Quick Annotation</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseline_clear_status</value></param>
<param><key>value</key><value>spectro_helper.baseline_clearer(clear_baseline)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseline_set_status</value></param>
<param><key>value</key><value>spectro_helper.baseline_setter(set_baseline)</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>clear_baseline</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@0:0,1,1,1</value></param>
<param><key>label</key><value>Clear Baseline</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>corr_probed</value></param>
<param><key>block_id</key><value>corr_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>complex(0.0,0.0)</value></param>
<param><key>poll_rate</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>curr_dx</value></param>
<param><key>value</key><value>spectro_helper.curr_diff(fft_probed,enable_normalize,fftsize,0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>curr_dx2</value></param>
<param><key>value</key><value>spectro_helper.curr_diff(fft_probed,enable_normalize,fftsize,1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>curr_tp_vect</value></param>
<param><key>value</key><value>spectro_helper.get_tp_vect(tp_pacer)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>custom_window</value></param>
<param><key>value</key><value>sinc*np.hamming(4*nchan)</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>dcblock</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@1:2,0,1,1</value></param>
<param><key>label</key><value>Enable DC block</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>dcgain</value></param>
<param><key>value</key><value>dcg</value></param>
<param><key>gui_hint</key><value>main_tab@1:0,2,1,1</value></param>
<param><key>label0</key><value>1e2</value></param>
<param><key>label1</key><value>1e3</value></param>
<param><key>label2</key><value>1e4</value></param>
<param><key>label3</key><value>1e5</value></param>
<param><key>label4</key><value>1e6</value></param>
<param><key>label</key><value>Detector Gain</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>100</value></param>
<param><key>option1</key><value>1000</value></param>
<param><key>option2</key><value>10000</value></param>
<param><key>option3</key><value>100000</value></param>
<param><key>option4</key><value>1000000</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>declination</value></param>
<param><key>value</key><value>spectro_helper.get_decln(ui_decln,decfile,tp_pacer)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ebw</value></param>
<param><key>value</key><value>(samp_rate*0.8)/1.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>enable_normalize</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft2_probed</value></param>
<param><key>block_id</key><value>fft2_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[-100.0]*fftsize</value></param>
<param><key>poll_rate</key><value>15</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>fft_avg</value></param>
<param><key>value</key><value>4</value></param>
<param><key>gui_hint</key><value>main_tab@0:1,2,1,1</value></param>
<param><key>label0</key><value>Low</value></param>
<param><key>label1</key><value>Medium</value></param>
<param><key>label2</key><value>High</value></param>
<param><key>label</key><value>FFT Averaging</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>4</value></param>
<param><key>option1</key><value>2</value></param>
<param><key>option2</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_log_status</value></param>
<param><key>value</key><value>spectro_helper.fft_log(fft_probed,fft2_probed,corr_probed,ifreq,samp_rate,longitude,enable_normalize,prefix,declination,rfilist,dcgain,fft_avg,mode,zerotime,decfile,tp_interval,spec_interval)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_probed</value></param>
<param><key>block_id</key><value>fft_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[-100.0]*fftsize</value></param>
<param><key>poll_rate</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fincr</value></param>
<param><key>value</key><value>(samp_rate/1.0e6)/fftsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frate</value></param>
<param><key>comment</key><value>Fringe rate</value></param>
<param><key>value</key><value>((180.0/3.14159)*wlam/baseline)/math.cos(math.radians(decln))</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>fringe_label</value></param>
<param><key>value</key><value>frate*240.0</value></param>
<param><key>gui_hint</key><value>main_tab@1:0,1,1,1</value></param>
<param><key>label</key><value>Fringe Period(secs)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frotate</value></param>
<param><key>value</key><value>spectro_helper.fringe_stop (tp_pacer, ra, decln, longitude, latitude, baseline, fstop, ang, ifreq)</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>fstop</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>main_tab@1:2,1,1,1</value></param>
<param><key>label</key><value>Fringe Stop</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gmdate</value></param>
<param><key>value</key><value>"%04d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ifreq</value></param>
<param><key>value</key><value>frequency</value></param>
<param><key>gui_hint</key><value>main_tab@0:0,2,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>igain</value></param>
<param><key>value</key><value>gain</value></param>
<param><key>gui_hint</key><value>main_tab@0:0,3,1,1</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ira</value></param>
<param><key>value</key><value>ra</value></param>
<param><key>gui_hint</key><value>main_tab@0:2,0,1,1</value></param>
<param><key>label</key><value>Target Right Ascension</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>km_incr</value></param>
<param><key>value</key><value>(((samp_rate/fftsize)/ifreq)*299792)*-1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ltp</value></param>
<param><key>value</key><value>time.gmtime(time.time())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mode_map</value></param>
<param><key>value</key><value>{"total" : "Continuum Power", "tp" : "Continuum Power", "diff" : "Differential/Added Power", "differential" : "Differential/Added Power", "correlator" : "Cross  Power", "interferometer": "Cross Power", "corr" : "Cross Power"}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nchan</value></param>
<param><key>value</key><value>fftsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pchanwidth</value></param>
<param><key>value</key><value>samp_rate/fbsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pparam</value></param>
<param><key>value</key><value>prefix+"-"+gmdate+"-psr.params" if psrmode != 0 else "/dev/null"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pparamstr</value></param>
<param><key>value</key><value>"%.2f,%.2f,%.4f,%.4f,%.4f,%d\n" % (psrate/1e3, pchanwidth/1e3, ifreq/1.0e6,samp_rate/1.0e6,ebw,fbsize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psrate</value></param>
<param><key>value</key><value>samp_rate/fftsize</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psrfilename</value></param>
<param><key>value</key><value>prefix+"-"+gmdate+"-psr.rfb8" if psrmode != 0 else "/dev/null"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(srate)</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>secondary_lmst_label</value></param>
<param><key>value</key><value>spectro_helper.lmst_string(time_pacer,longitude)</value></param>
<param><key>gui_hint</key><value>main_tab@1:0,0,1,1</value></param>
<param><key>label</key><value>LMST</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>set_baseline</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@0:0,0,1,1</value></param>
<param><key>label</key><value>Set Baseline</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sinc</value></param>
<param><key>value</key><value>np.sinc(sinc_sample_locations/np.pi)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sinc_sample_locations</value></param>
<param><key>value</key><value>np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/nchan)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spec_labels</value></param>
<param><key>value</key><value>spectro_helper.get_spec_labels(mode)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_km</value></param>
<param><key>value</key><value>spectro_helper.doppler_start(ifreq,dfreq,samp_rate)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>time_pacer</value></param>
<param><key>block_id</key><value>fft_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[-100.0]*fftsize</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tp_pacer</value></param>
<param><key>block_id</key><value>fft_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[-100.0]*fftsize</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ui_decln</value></param>
<param><key>value</key><value>decln</value></param>
<param><key>gui_hint</key><value>main_tab@0:1,0,1,1</value></param>
<param><key>label</key><value>Declination</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>spectro_helper.init_zero_map(zerofile)</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>spectro_helper.lmst_string(time_pacer,longitude)</value></param>
<param><key>gui_hint</key><value>main_tab@0:1,3,1,1</value></param>
<param><key>label</key><value>Local Mean Sidereal Time</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>wchan</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>main_tab@0:2,3,1,1</value></param>
<param><key>label0</key><value>0</value></param>
<param><key>label1</key><value>1</value></param>
<param><key>label</key><value>Waterfall Chan</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>win</value></param>
<param><key>value</key><value>fft.window.blackmanharris(fftsize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>winsum</value></param>
<param><key>value</key><value>sum(map(lambda x:x*x, win))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wlam</value></param>
<param><key>comment</key><value>Wavelength in meters</value></param>
<param><key>value</key><value>299792000.0/ifreq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wrstatus</value></param>
<param><key>value</key><value>open(pparam, "w").write(pparamstr)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>abw</value></param>
<param><key>label</key><value>Analog  bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>RX2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baseline</value></param>
<param><key>label</key><value>Baseline length</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>99.3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bbgain</value></param>
<param><key>label</key><value>Baseband Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>curr_dx</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>curr_tp_vect[0]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>3600</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0_0</value></param>
<param><key>const</key><value>curr_tp_vect[1]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>3600</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_1</value></param>
<param><key>const</key><value>curr_dx2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_1</value></param>
<param><key>comment</key><value>Add a teensy weensy value here
To keep from SIGFPE
When stream is all 0s.</value></param>
<param><key>const</key><value>1.0e-14</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0_0</value></param>
<param><key>delay</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_1</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>4*fftsize</value></param>
<param><key>n</key><value>5*fftsize</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>m</key><value>4*fftsize</value></param>
<param><key>n</key><value>5*fftsize</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>(samp_rate/fftsize)/50</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>(samp_rate/fftsize)/50</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>int(samp_rate/10)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>comment</key><value>The basic correlation operation
Conjugate multiply of the two streams</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>Allow for phase-adjust on one side</value></param>
<param><key>const</key><value>frotate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>[0.0]*fftsize</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>comment</key><value>When != 0, this turns on DC blocking</value></param>
<param><key>const</key><value>dcblock</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3</value></param>
<param><key>const</key><value>1.0 if wchan == 0 else 0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3_0</value></param>
<param><key>const</key><value>1.0  if wchan == 1 else 0.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4</value></param>
<param><key>const</key><value>custom_window[2*nchan:3*nchan]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4_0</value></param>
<param><key>const</key><value>custom_window[-nchan:]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4_0_0</value></param>
<param><key>const</key><value>custom_window[-nchan:]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4_1</value></param>
<param><key>const</key><value>custom_window[nchan:2*nchan]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4_1_0</value></param>
<param><key>const</key><value>custom_window[0:nchan]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4_1_0_0</value></param>
<param><key>const</key><value>custom_window[0:nchan]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4_1_1</value></param>
<param><key>const</key><value>custom_window[nchan:2*nchan]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4_2</value></param>
<param><key>const</key><value>custom_window[2*nchan:3*nchan]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>k</key><value>-20*math.log10(fftsize)-10.0*math.log10(winsum/fftsize)-20*math.log10(1)</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>k</key><value>-20*math.log10(fftsize)-10.0*math.log10(winsum/fftsize)-20*math.log10(1)</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>3600</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>40</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>3600</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock</value></param>
<param><key>label</key><value>Clock Source</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>default</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>corr_probe</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dcg</value></param>
<param><key>label</key><value>Detector DC Gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decfile</value></param>
<param><key>label</key><value>Declination File Name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decln</value></param>
<param><key>label</key><value>Observing Declination</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>SDR Device Name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"rtl=0 file=/dev/zero,rate=5e6"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dfreq</value></param>
<param><key>label</key><value>Alternet Doppler Cente Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fbsize</value></param>
<param><key>label</key><value>PSR Filterbank size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>fft2_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>fft_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>label</key><value>FFT size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1420.4058e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ifgain</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio import fft</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>latitude</value></param>
<param><key>label</key><value>Local Latitude</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>44.9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>longitude</value></param>
<param><key>label</key><value>Local Longitude</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-76.03</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>main_tab</value></param>
<param><key>label0</key><value>Spectral</value></param>
<param><key>label1</key><value>Continuum</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mode</value></param>
<param><key>label</key><value>Operation Mode</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"total"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>We synthesize a strip chart by updating
a vector from a function probe
That vector contains the current strip-chart
values.</value></param>
<param><key>note</key><value>Such stripchart...</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Just a pacing source</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>comment</key><value>Implement simple DC-block, very cheaply.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>comment</key><value>******* GUI ZONE ******
GUI CONTROL OBJECTS GO HERE!!</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>comment</key><value>**** PARAMETER ZONE *****
COMMAND-LINE PARAMS GO HERE!!</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5</value></param>
<param><key>comment</key><value>The two main FFT pathways
Connected to the input filters</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6</value></param>
<param><key>comment</key><value>Compute a bunch of parameters to
write to a parameters file for psrmode != 0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_7</value></param>
<param><key>comment</key><value>None of this pulsar stuff is
fully fleshed out yet
Probably fold in code from
pulsar_filterbank when I'm 
happy with it.</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>antenna</value></param>
<param><key>bb_gain0</key><value>bbgain</value></param>
<param><key>bw0</key><value>abw</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>ifreq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>ifgain</value></param>
<param><key>gain0</key><value>igain</value></param>
<param><key>ant1</key><value>antenna</value></param>
<param><key>bb_gain1</key><value>bbgain</value></param>
<param><key>bw1</key><value>abw</value></param>
<param><key>dc_offset_mode1</key><value>2</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>ifreq</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>if_gain1</key><value>ifgain</value></param>
<param><key>iq_balance_mode1</key><value>0</value></param>
<param><key>gain1</key><value>igain </value></param>
<param><key>args</key><value>device</value></param>
<param><key>clock_source0</key><value>clock</value></param>
<param><key>time_source0</key><value>ppstime</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppstime</value></param>
<param><key>label</key><value>Time Source</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>internal</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>Data File Prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"h1"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psrmode</value></param>
<param><key>label</key><value>Enable PSR mode</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>spec_tab@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>spec_labels[0]</value></param>
<param><key>label2</key><value>spec_labels[1]</value></param>
<param><key>name</key><value>"Doppler Velocity"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>1.0/15</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_axis_label</key><value>"Doppler Velocity (km/s)"</value></param>
<param><key>x_start</key><value>start_km</value></param>
<param><key>x_step</key><value>km_incr</value></param>
<param><key>x_units</key><value>"km/s"</value></param>
<param><key>ymax</key><value>+5</value></param>
<param><key>ymin</key><value>-1</value></param>
<param><key>y_axis_label</key><value>"Rel. Power (dB)"</value></param>
<param><key>y_units</key><value>"dB"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>gui_hint</key><value>main_tab@1:3,0,2,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>spectro_helper.plotlabel(mode,0)</value></param>
<param><key>label2</key><value>spectro_helper.plotlabel(mode,1)</value></param>
<param><key>name</key><value>mode_map[mode]</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>1.0/5.0</value></param>
<param><key>vlen</key><value>3600</value></param>
<param><key>x_axis_label</key><value>"Time (Minutes)"</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>-(1.0/60.0)</value></param>
<param><key>x_units</key><value>"Mins"</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>0.0</value></param>
<param><key>y_axis_label</key><value>"Deteced Power (arb units)"</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>spec_tab@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>spec_labels[0]</value></param>
<param><key>label2</key><value>spec_labels[1]</value></param>
<param><key>name</key><value>"Frequency (MHz)"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>1.0/15</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_axis_label</key><value>"Frequency (MHz)"</value></param>
<param><key>x_start</key><value>(ifreq-samp_rate/2)/1.0e6</value></param>
<param><key>x_step</key><value>fincr</value></param>
<param><key>x_units</key><value>"MHz"</value></param>
<param><key>ymax</key><value>+5</value></param>
<param><key>ymin</key><value>-1</value></param>
<param><key>y_axis_label</key><value>"Rel. Power (dB)"</value></param>
<param><key>y_units</key><value>"dB"</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>ifreq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>spec_tab@2</value></param>
<param><key>int_max</key><value>-40</value></param>
<param><key>int_min</key><value>-90</value></param>
<param><key>color1</key><value>3</value></param>
<param><key>name</key><value>Spectrogram</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ra</value></param>
<param><key>label</key><value>Target RA</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>12.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfilist</value></param>
<param><key>label</key><value>RFI Frequency List</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/(samp_rate/(0.1*fftsize))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0</value></param>
<param><key>alpha</key><value>1.0/(samp_rate/(0.1*fftsize))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_1</value></param>
<param><key>alpha</key><value>1.0/(samp_rate*25)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_2</value></param>
<param><key>alpha</key><value>1.0/((frate*240)*1.25*5)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spec_interval</value></param>
<param><key>label</key><value>Spectral Logging Interval</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>spec_tab</value></param>
<param><key>gui_hint</key><value>main_tab@0:3,0,1,4</value></param>
<param><key>label0</key><value>Doppler</value></param>
<param><key>label1</key><value>Frequency</value></param>
<param><key>label2</key><value>Waterfall</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>spectro_helper</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import sys
import os
import time
import ephem
import operator
import math
import numpy


zeromap = {}

lastt = time.time()
lasttpt = time.time()
fft_buffer = [1.0e-25]*2048
fft2_buffer = [0.0]*2048
baseline_buffer=[0.0]*2048
baseline_buffer2=[0.0]*2048
freq_mask=[1.0]*2048
freq_mask_processed=False
tpwra=-99
tpwrb=-99
first_time = 0
pacet = time.time()
corr_sin = 1.0e-12
corr_cos = 1.0e-12
dpwr=0.0
apwr=0.0
import copy

def do_annotation(ra,dec,baseline,annotation,bw,abw,freq,srate,prefix):
    ltp = time.gmtime()
    if len(annotation) &lt;= 0:
        return True
    fn = "%s%04d%02d%02d-annotation.txt" % (prefix, ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
    fp = open(fn, "a")
    fp.write ("Annotation update: %04d%02d%02d-%02d:%02d:%02d\n" % 
        (ltp.tm_year, ltp.tm_mon, ltp.tm_mday, ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
    fp.write ("RA: %6.2f\n" % ra)
    fp.write ("DEC: %6.2f\n" % dec)
    fp.write ("Baseline length: %6.2fm\n" % baseline)
    fp.write ("Annotation: %s\n" % annotation)
    fp.write ("Input Filter Bandwidth: %6.2fMHz\n" % (bw/1.0e6))
    fp.write ("Analog Bandwidth: %6.2fMHz\n" % (abw/1.0e6))
    fp.write ("Frequency: %8.4fMHz\n" % (freq/1.0e6))
    fp.write ("Sample rate: %6.2fMsps\n\n" % (srate/1.0e6))
    fp.close()
    return True
    
    
def fft_log(p,p2,corr,frq,bw,longitude,normalize,prefix,decln,flist,again,ffa,mode,zt,decfile,tpi,spi):
    global fft_buffer
    global first_time
    global lastt
    global lasttpt
    global baseline_buffer
    global baseline_buffer2
    global fft2_buffer
    global tpwra, tpwrb
    global dpwr
    global apwr
    global freq_mask
    global freq_mask_processed
    global pacet
    global corr_cos, corr_sin
    global zeromap

    preflist=prefix.split(",")
    
    if ((time.time() - pacet) &lt; 0.05):
        return False
    
    pacet = time.time()
    
    if (len(p) != len(freq_mask)):
        fft_buffer = [1.0e-25]*len(p)
        fft2_buffer = [0.0]*len(p)
        baseline_buffer=[0.0]*len(p)
        freq_mask=[1.0]*len(p)
    
    fplen = float(len(p))
    if flist != "" and freq_mask_processed == False:
        nmsks = 0
        freq_mask_processed = True
        stf = frq-(bw/2.0)
        incr = bw/fplen
        flist = flist.split(",")
        for i in range(0,len(freq_mask)):
            for f in flist:
                if math.fabs(stf-float(f)) &lt;= (incr*2.5):
                    freq_mask[i] = 1.0e-15
                    print "Setting mask at F %f position %d (%f)" % (float(f), i, incr*float(i))
                    nmsks += 1
            stf += incr
        print "Total mask percentage %f" % ((float(nmsks)/fplen)*100.0)
                
    if fft_buffer[10] &lt; 1.0e-24:
        fft_buffer = numpy.copy(p)

    pwra = 0.0
    pwrb = 0.0
    diff = 0.0
    a = 0.05 * ffa

    
    #
    # Use numpy to process the log10-FFT buffers and turn them
    #  into linear values
    #
    ta = numpy.divide(p,[10.0]*len(p))
    ta = numpy.power([10.0]*len(ta),ta)
    ta = numpy.multiply(ta,freq_mask)
    pwra = numpy.sum(ta)
    
    tb = numpy.divide(p2,[10.0]*len(p))
    tb = numpy.power([10.0]*len(tb),tb)
    tb = numpy.multiply(tb,freq_mask)
    pwrb = numpy.sum(tb)
    
    ffts = [ta, tb]
    
    w = 0
    for  tf in ffts:
        #
        # To guard against log10 blowing up
        #
        tf = numpy.add([1.0e-22]*len(tf), tf)

        #
        # Integrate as a vector
        #
        tf = numpy.multiply([a]*len(tf),tf)
        tf2 = numpy.multiply([1.0-a]*len(tf), fft_buffer if w == 0 else fft2_buffer)
        tf = numpy.add(tf2,tf)

        #
        # Update it BEFORE we convert to log10, dummy
        #
        if (w == 0):
            fft_buffer = tf
        else:
            fft2_buffer = tf
        
        w += 1
    
    
    atp=0.02
    #
    # Gain settings
    #
    corr_a = corr.real * again
    corr_b = corr.imag * again
    pwra *= again
    pwrb *= again
    
    #
    # Prime the integrator
    #
    if (tpwra &lt; -10):
        tpwra = pwra
        tpwrb = pwrb
        
    if (corr_cos &lt; -1.0e-10):
        corr_cos = corr_a
        corr_sin = corr_b
    
    #
    # Integration
    #
    corr_cos = (atp * corr_a) + ((1.0 - atp)*corr_cos)
    corr_sin = (atp * corr_b) + ((1.0 - atp)*corr_sin)

    tpwra = (atp * pwra) + ((1.0 - atp)*tpwra)
    tpwrb = (atp * pwrb) + ((1.0 - atp)*tpwrb)
    
    diff = tpwra - tpwrb
    added = tpwra + tpwrb

    if (first_time == 0):
        first_time = int(time.time())
    
    dpwr = tpwra   
    apwr = 0.0
    if (mode == "differential" or mode == "diff"):
        dpwr = diff
        apwr = added
    
    if (mode == "interferometer" or mode == "corr" or mode == "correlator"):
        dpwr = corr_cos
        apwr = corr_sin

    #
    # Allow integrators to settle, etc, so don't write "ramp up" data
    #
    if ((time.time() - first_time) &gt; 20):
            
        if (time.time() - lasttpt) &gt;= tpi:
            lasttpt = time.time()
            
            ltp = time.gmtime()
            for prefix in preflist:
                fn="%s%04d%02d%02d-tp.csv" % (prefix, ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
                f = open (fn, "a")
                f.write ("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                f.write ("%s," % cur_sidereal(longitude))
                f.write("%5.5f," % (frq/1.0e6))
                f.write("%5.5f," % bw)
                f.write("%5.1f," % decln)
                f.write("%10.7f," % tpwra)
                f.write("%10.7f," % tpwrb)
                f.write("%10.7f," % diff)
                f.write("%10.7f," % added)
                f.write("%10.7f,%10.7f\n" %  (corr_cos, corr_sin))
                f.close()
        
        if (time.time() - lastt) &gt;= spi:
            lastt = time.time()
            ltp = time.gmtime()
            
            ffts = [fft_buffer, fft2_buffer]
            for w in [0,1]:
                for prefix in preflist:
                    fn = "%s%04d%02d%02d-%d-spec.csv" % (prefix, ltp.tm_year, ltp.tm_mon, ltp.tm_mday, w)
                    f = open (fn, "a")
                    f.write ("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
                    f.write ("%s," % cur_sidereal(longitude))
                    f.write("%5.5f," % (frq/1.0e6))
                    f.write("%5.5f," % bw)
                    f.write("%5.1f," % decln)
                    
                    st = cur_sidereal(longitude)
                    st = st.split(",")
                    st_h = float(st[0])
                    st_h += float(st[1])/60.0
                    st_h += float(st[2])/3600.0
                        
                    for i in range(0,len(ffts[w])):
                        try:
                            f.write("%6.2f," % (math.log10(ffts[w][i])*10.0))
                        except:
                            f.write("???,")
                    f.write ("\n")
                    f.close()
                    
                    d_ndx = int(decln)
                    if (d_ndx in zeromap and (st_h - zeromap[d_ndx]) &lt; (35.0/3600.0)):
                        baseline_setter(1)
            return 1
        
    return 0
 
def smooth(vect,a=0.4):
    ovect=[0]*len(vect)
    val=vect[0]
    for i in range(0,len(vect)):
        val = (a*vect[i]) + ((1.0 - a)*val)
        ovect[i] = val
    
    return ovect   
    
def avgvect(v1, v2):
    q = map(operator.add, v1, v2)
    return map(operator.div, q, [2]*len(v1))

def cur_sidereal(longitude):
    longstr = "%02d" % int(longitude)
    longstr = longstr + ":"
    longitude = abs(longitude)
    frac = longitude - int(longitude)
    frac *= 60
    mins = int(frac)
    longstr += "%02d" % mins
    longstr += ":00"
    x = ephem.Observer()
    x.date = ephem.now()
    x.long = longstr
    jdate = ephem.julian_date(x)
    tokens=str(x.sidereal_time()).split(":")
    hours=int(tokens[0])
    minutes=int(tokens[1])
    seconds=int(float(tokens[2]))
    sidt = "%02d,%02d,%02d" % (hours, minutes, seconds)
    return (sidt)
    
def curr_findx(pace):
    global  sched_index
    global schedule
    global baseline_count
    global MAX_BASELINE
    
    if baseline_count &gt; MAX_BASELINE:
        return 0

    cur=schedule[sched_index]
    sched_index = sched_index + 1
    if sched_index &gt;= len(schedule):
        sched_index = 0
    return cur


#
# Get (baselined) FFT buffer, whichever is selected for display
#
def curr_diff(pace,normalize,expected,which):
    global fft_buffer
    global baseline_buffer
    global fft2_buffer
    global baseline_buffer2
    
    inbuf = [fft_buffer, fft2_buffer]
    basebuf = [baseline_buffer, baseline_buffer2]
    
    if (len(fft_buffer) != expected):
        return ([-120.0]*expected)
    
    if (numpy.sum(basebuf[which]) == 0.0):
        x = smooth(inbuf[which])
    else:
        y = map(operator.add, basebuf[which], [1.0e-24]*len(basebuf[which]))
        x = map(operator.truediv, smooth(inbuf[which]), smooth(y))
    x = numpy.add(x, [1.0e-24]*len(x))
    x = numpy.abs(x)
    return numpy.multiply(numpy.log10(x),[10.0]*len(x))
    
def not_the_norm(vect):
    m=min(vect)
    s=[m]*len(vect)
    return map(operator.sub, vect, s)

def baseline_setter(thing):
    global baseline_buffer
    global baseline_buffer2
    global fft_buffer
    global fft_buffer2
    
    if thing != 0:
        baseline_buffer = smooth(fft_buffer,a=0.5)
        baseline_buffer = numpy.multiply(baseline_buffer,[0.95]*len(baseline_buffer))
        baseline_buffer2 = smooth(fft2_buffer,a=0.5)
        baseline_buffer2 = numpy.multiply(baseline_buffer2, [0.95]*len(baseline_buffer2))

def baseline_clearer(thing):
    global baseline_buffer
    global fft_buffer
    global baseline_buffer2
    global fft2_buffer
    
    if thing != 0:
        baseline_buffer = [0.0]*len(fft_buffer)
        baseline_buffer2 = [0.0]*len(fft2_buffer)

def lmst_string(pacer,longitude):
    return cur_sidereal(longitude).replace(",", ":")


TPLEN=3600
tp_vect=[0.0]*TPLEN
tp_vect2=[0.0]*TPLEN
def get_tp_vect(pacer):
    global tp_vect
    global tp_vect2
    global dpwr
    global TPLEN
    
    
    tp_vect=tp_vect[0:(TPLEN-1)]
    tp_vect=[dpwr]+tp_vect
    
    tp_vect2=tp_vect2[0:(TPLEN-1)]
    tp_vect2=[apwr]+tp_vect2
    
    if len(tp_vect) != TPLEN:
        print "Blarf!!! short TP_VECT"
    
    return ([tp_vect,tp_vect2])
            

tpwr = 0 
def lmst_hours(pacer,longitude):
    x = lmst_string(1,longitude)
    
    x = x.split(":")
    hours = float(x[0])
    hours += float(x[1])/60.0
    hours += float(x[2])/3600.0
    
    return hours

#
#
# Calculations for automated fringe-stopping
#
# We are called on a regular basis to produce a complex rotation value that is
#  applied to one leg of the interferometer, to reduce the fringe frequency to
#  close-to zero, thus allowing longer integration times.
#
def ha (ra,longit):
    #
    # First get current sidereal time as as HH:MM:SS string
    #
    lmst = cur_sidereal (longit)
    parts = lmst.split(",")
    
    #
    # Re-express lmst (string) as a decimal hours
    #
    lmst = float(parts[0])
    lmst += float(parts[1]) / 60.0
    lmst += float(parts[2]) / 3600.0
    
    #
    # Now compute relative hour-angle between us, and the object in question (at some RA)
    #   When we're done, we have the relative hour-angle in radians
    #
    h = ra - lmst
    return (h)
#
# Phase accumulator
#
phase_accum = 0.0

#
# For time-delta calcs
#
last_time_phase = -99.0

#
# Earth rotation in radians/second
#
earth = math.radians(360.0 / 86400.0)

#
# Since part of the calculation only needs to be done when baseline or
#  frequency changes, we keep 'em global
gbaseline = 0.0
gfreq = 0.0
basefreqrot = 0.0

#
# Another part only changes when dec/latit changes
#
gdec = -99.0
glatit = -99.0
declatrot = 0.0

#
# The combination of the two
#
baserot = 0.0

#
# Speed of light, in case it wasn't obvious :)
#
C = 299792000.0

#
#
# Compute phase-rotation value based either on manual input, or automatic
#   fringe rotation
#
# pacer   - ignored, simply used as a "dummy" variable in the flow-graph to
#           make sure that we're called regularly.
# ra       - The RA in fractional hours
# dec      - The DEC in fractional degrees
# longit   - Our geographic longitude
# latit    - Our geographic latitude
# baseline - Baseline length, in meters
# ena      - Whether automagic or manual is in use
# manval   - The manual value
# freq     - The sky frequency
#
#
# These calculations assume a meridian-transit type setup, with a strictly east-west baseline
#
def fringe_stop (pacer, ra, dec, longit, latit, baseline, ena, manval, freq):
    global phase_accum
    global last_time_phase
    global earth
    global gbaseline
    global gfreq
    global basefreqrot
    global declatrot
    global gdec
    global glatit
    global baserot
 
    #
    # Just compute the fixed-value from the degrees input by the UI
    #
    if ena == False:
        radians = math.radians(manval)
        return (complex(math.cos(radians),math.sin(radians)))

   
    #
    # Handle initialization of our time-delta calculator
    #
    if last_time_phase &lt; 0:
        last_time_phase = time.time()

    #
    # Compute time delta compared to last-time
    #
    now = time.time()
    tdelt = now - last_time_phase
    
    #
    # Remember "now" for next time
    #
    last_time_phase = now
    
    changed = False
    
    #
    # If baseline or freq parameters have changed
    #
    if baseline != gbaseline or freq != gfreq:
        gbaseline = baseline
        gfreq = freq
        basefreqrot = (baseline * earth)/(C / freq)
        changed = True
    
    #
    # If dec or latit changes
    #
    if dec != gdec or latit != glatit:
        gdec = dec
        glatit = latit
        declatrot = math.cos(math.radians(dec))*math.cos(math.radians(latit))
        changed = True
    
    #
    # Update the combined "baserot"
    #
    if changed == True:
        baserot = basefreqrot * declatrot
        
    #
    # First get current sidereal time as as HH:MM:SS string
    #
    lmst = cur_sidereal (longit)
    parts = lmst.split(",")
    
    #
    # Re-express lmst (string) as a decimal hours
    #
    lmst = float(parts[0])
    lmst += float(parts[1]) / 60.0
    lmst += float(parts[2]) / 3600.0
    
    #
    # Now compute relative hour-angle between us, and the object in question (at some RA)
    #   When we're done, we have the relative hour-angle in radians
    #
    h = ra - lmst
    h *= math.radians((360.0 / 24.0))
        
    #
    # Compute fringe rate in radians/hour
    #
    # h       - relative hour-angle, in radians between us and source
    #
    # Other parameters to the equation don't change with time, so they're
    #   efficiently pre-computed above, and re-computed when the input
    #   parameters change
    #
    F = baserot*math.sin(h)
    
    #
    # Because I get lost in the units, the above may be in radians/hour
    #   or radians/second so we can just adjust this scaling for the calculation below
    #
    scale = 1.0/3600.0
    
    #
    # Update the phase accumulator (stored in radians)
    # Handle phase-wrap gracefully
    # (although, the Python transcendentals handle this just fine themselves)
    #
    phase_accum += tdelt*(F * scale)
    if phase_accum &gt; 2.0*math.pi:
        phase_accum -= (2.0*math.pi)
    
    #
    # We return a value that can be used by the phase rotator in the flow-graph
    #
    rval = complex(math.cos(phase_accum),math.sin(phase_accum))
    return (rval)

def doppler_start(ifreq, dfreq, bw):
    if (dfreq == 0.0):
        stf = ifreq - bw/2.0
        dop = (ifreq - stf) / ifreq
        dop *= 299792.0
    else:
        stf = ifreq - bw/2.0
        dop = (dfreq - stf) / dfreq
        dop *= 299792.0
    return dop

ui_decln = [time.time(), None]
f_decln = [time.time(), None]
def get_decln(decln,decfile,dummy):
    global ui_decln
    global f_decln
    try:
        newdec = open(decfile,"r").readline().strip("\n")
        newdec = float(newdec)
        if (newdec != f_decln):
            f_decln = [time.time(), none]
    except:
        pass
    
    if (decln != ui_decln):
        ui_decln = [time.time(), decln]

    if (f_decln[0] &gt; ui_decln[0]):
        return(f_decln[1])
    else:
        return(ui_decln[1])
 
def plotlabel(mode, which):
    w1 = {"total" : "TP", "tp" : "TP", "diff" : "Diff", "differential" : "Diff", "interf" : "Cos", "interferometer" : "Cos",
        "correlator" : "Cos"}
    w2 = {"total" : "Zero", "tp" : "Zero", "diff" : "Sum", "differential" : "Sum", "interf" : "Sin", "interferometer" : "Sin",
        "correlator" : "Sin"}
    
    ary = [w1,w2]
    
    di = ary[which]
    return (di[mode])

def get_spec_labels(mode):
    w1 = {"total" : "SKY", "tp" : "SKY", "diff" : "SKY", "differential" : "SKY", "interf" : "East", "interferometer" : "East",
        "correlator" : "East"}
    w2 = {"total" : "Zero", "tp" : "Zero", "diff" : "REF", "differential" : "REF", "interf" : "West", "interferometer" : "West",
        "correlator" : "West"}
    
    return ([w1[mode],w2[mode]])
    
def init_zero_map(zf):
    global zeromap
    cnt = 0
    
    if ("" != zf and zf != None):
        try:
            f = open(zf, "r")
            lines = f.readlines()
            f.close()
            for l in lines:
                l = l.replace("\n", "")
                ts = l.split(" ")
                zeromap[int(ts[0])] = float(ts[1])
                cnt += 1
        except:
            pass
    return cnt
            
</value></param>
<param><key>comment</key><value>IMPORTED MODULE
A bunch of helper bits and pieces for logging, etc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.56e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tp_interval</value></param>
<param><key>label</key><value>TP Logging Interval</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>fft_decim_vectors</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>fft_filtered</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>stream_id</key><value>fft2_filtered</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>Chan0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_0</value></param>
<param><key>stream_id</key><value>Chan1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>pfb0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_0</value></param>
<param><key>stream_id</key><value>pfb1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4</value></param>
<param><key>stream_id</key><value>pfb_out0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4_0</value></param>
<param><key>stream_id</key><value>pfb_out1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>fft_decim_vectors</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>fft_filtered</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>fft2_filtered</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>Chan0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>Chan1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>Chan0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_0</value></param>
<param><key>stream_id</key><value>Chan1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>Chan0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4_0</value></param>
<param><key>stream_id</key><value>Chan1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_5</value></param>
<param><key>stream_id</key><value>pfb0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_5_0</value></param>
<param><key>stream_id</key><value>pfb1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_6</value></param>
<param><key>stream_id</key><value>pfb_out0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_6_0</value></param>
<param><key>stream_id</key><value>pfb_out1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zerofile</value></param>
<param><key>label</key><value>File containing zeroing map</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zerotime</value></param>
<param><key>label</key><value>SIdereal time for auto baseline set</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>99.3</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>virtual_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1_0</source_block_id><sink_block_id>virtual_sink_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_4_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_4_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_4_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_4_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_4_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_0_0</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_1_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_1_0_0</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_1_1</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4_2</source_block_id><sink_block_id>blocks_add_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>fft_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>fft2_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>virtual_sink_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>corr_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_2_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_1</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>blocks_multiply_const_vxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>blocks_multiply_const_vxx_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5_0</source_block_id><sink_block_id>blocks_delay_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5_0</source_block_id><sink_block_id>blocks_delay_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5_0</source_block_id><sink_block_id>blocks_delay_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_4_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_6</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_6_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
